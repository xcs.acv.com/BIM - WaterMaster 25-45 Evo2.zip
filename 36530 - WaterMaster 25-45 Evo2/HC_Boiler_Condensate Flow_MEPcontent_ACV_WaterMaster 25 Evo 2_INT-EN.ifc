Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
Time: 2025-10-22T10:06:00+02:00
Written by: ODA SDAI 22.12
Made in: 23.0.1.318 - Exporter 23.0.1.318 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1899
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcBoiler: HC_Boiler_Condensate Flow_MEPcontent_ACV_WaterMaster 25-45 Evo2_INT-EN:WaterMaster 25 Evo 2, HC_Boiler_Condensate Flow_MEPcontent_ACV_WaterMaster 25-45 Evo2_INT-EN:WaterMaster 25 Evo 2:18525
In: Level 1
Type - Material: Color RGB 073-073-073, Color RGB 222-222-222, Color RGB 237-028-036, Color RGB 143-145-144, Color RGB 187-080-046, Color RGB 129-158-173
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 745 mm; Domestic Cold Water Diameter: 25.4 mm; Domestic Hot Water Diameter: 25.4 mm; Flue Gas Diameter: 80 mm; Gas Diameter: 19.05 mm; Height: 1780 mm; Hydronic Return Diameter: 25.4 mm; Hydronic Supply Diameter: 25.4 mm; Supply Air Diameter: 125 mm; Use Nominal Diameter: yes; Width: 600 mm
Type - Electrical - Current: 0.7 A; Hertz: 50 Hz; Input: 25000 W; Voltage: 230 V
Type - Identity Data - Article Description: Direct gas fired condensing water heater; Article Type: WaterMaster 25 Evo 2; Base Family Version: 25.12; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Direct gas fired condensing water heater; EMCS Version: 5.0; ETIM Article Class: EC011390; Family Version: 25.12; GLN: 5400891000007; GTIN: 5400891542453; Manufacturer: ACV; Manufacturer Art. No.: 554245; Manufacturer URL: https://www.acv.com/international; MEPcontent Class: BOILER_CONDENSATE_FLOW; Model: WaterMaster 25 Evo 2; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Product Line: WaterMaster Evo 2; Revit Version: 2023; Type Name: WaterMaster 25 Evo 2; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Blue: Color RGB 129-158-173; Dark Grey: Color RGB 073-073-073; Glass: Color RGB 218-227-224; Light Grey: Color RGB 143-145-144; Orange Connection: Color RGB 187-080-046; Red: Color RGB 237-028-036; White: Color RGB 222-222-222
Type - Mechanical - DHW Continuous Flow 60°C: 0.131389 m3/s; Gas Flow Rate Max: 0.719444 m3/s; Gas Flow Rate Min: 0.144444 m3/s; Maximum Supply Temperature (Operating Temperature): 87 C; Max Pressure DHW: 860000 Pa; Max Pressure Heating: 300000 Pa; Total Capacity: 0.196 m3; Weight: 177 kg
Type - Other - Category: Mechanical Equipment; A: 1780 mm; B: 600 mm; Bottom Clearance: 0 mm; Chimney Agreement: B23-B23P-C13-C33-C53-C63-C83-C82; Class: 6; F: 1680 mm; Family Name: HC_Boiler_Condensate Flow_MEPcontent_ACV_WaterMaster 25-45 Evo2_INT-EN; G: 450 mm; H: 300 mm; I: 0 mm; J: 110 mm; K: 1730 mm; L: 1625 mm; M: 1415 mm; Maine Body Depth: 707 mm; N: 710 mm; O: 585 mm; P: 285 mm; Profile: XXL; Space Heating Energy Efficiency Class: -; Water Heating Energy Efficiency Class: A
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACV
Pset_BoilerTypeCommon - Reference: WaterMaster 25 Evo 2; sets with these values: 2
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 10.8639 m2; Volume: 0.74202 m3
Electrical - Power: 0 W
Identity Data - Mark: 1
Mechanical - System Classification: Undefined,Hydronic Return,Hydronic Supply,Supply Air,Exhaust Air,Power,Domestic Cold Water,Domestic Hot Water
Mechanical - Flow - Domestic Cold Water Flow: 0 m3/s; Domestic Hot Water Flow: 0 m3/s; Flue Gas Flow: 0 m3/s; Gas Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; Supply Air Flow: 0 m3/s
Other - Back Clearance Safe: 400 mm; Family: HC_Boiler_Condensate Flow_MEPcontent_ACV_WaterMaster 25-45 Evo2_INT-EN; Family and Type: HC_Boiler_Condensate Flow_MEPcontent_ACV_WaterMaster 25-45 Evo2_INT-EN: WaterMaster 25 Evo 2; Left Clearance Safe: 600 mm; Right Clearance Safe: 250 mm; Top Clearance Safe: 200 mm; Type: WaterMaster 25 Evo 2; Type Id: 18506
Phasing - Phase Created: New Construction
Visibility - Back Clearance: 400 mm; Left Clearance: 600 mm; Right Clearance: 250 mm; Show Service Area: no; Top Clearance: 200 mm

# IfcDistributionPort (8)
Description: Flow
Name | FlowDirection | PredefinedType | SystemType
Port_18525 | SINK | DUCT | VENTILATION
Port_18525 | SOURCE | PIPE | DOMESTICHOTWATER
Port_18525 | SOURCE | PIPE | HEATING
Port_18525 | SINK | PIPE | HEATING
Port_18525 | SINK | PIPE | DOMESTICCOLDWATER
Port_18525 | SINK | PIPE
Port_18525 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_18525 | SOURCE | DUCT | EXHAUST
